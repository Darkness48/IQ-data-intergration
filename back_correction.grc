options:
  parameters:
    generate_options: qt_gui
    id: back_correction
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: high
  id: variable
  parameters:
    value: '1421000000'
  states: {}
- name: hydro
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: low
  id: variable
  parameters:
    value: '1419000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: thro
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: vec
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high
    low_cutoff_freq: low
    samp_rate: thro
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: vec
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\임채진\back_ground\test.wav
    type: float
    vlen: vec
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
    vlen: vec
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1'
    max_iter: '4000'
    scale: '1'
    type: float
    vlen: '8192'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: float
    vlen: vec
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: thro
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import time
      import os
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, vector_length=1024, interval_sec=10, directory="data"):
              gr.sync_block.__init__(
                  self,
                  name='RollingFileWriter',
                  in_sig=[(np.float32, int(vector_length))],
                  out_sig=[]
              )
              self.vector_length = int(vector_length)
              self.interval_sec = float(interval_sec)
              self.directory = directory
              
              self.buffer = []
              self.start_time = time.time()
              self.current_filename = os.path.join(self.directory, "latest_spectrum.npy")

              if not os.path.exists(self.directory):
                  os.makedirs(self.directory)

          def work(self, input_items, output_items):
              now = time.time()
              # 입력 FFT 벡터 받아서 복사 후 버퍼에 저장
              self.buffer.append(input_items[0][0].copy())

              # 10초 경과시 파일 저장 및 이전 파일 삭제
              if now - self.start_time >= self.interval_sec:
                  # 이전 파일 삭제
                  if os.path.isfile(self.current_filename):
                      try:
                          os.remove(self.current_filename)
                      except Exception as e:
                          print(f"Error deleting old file: {e}")
                  
                  # 버퍼를 numpy 배열로 변환 후 저장
                  data_to_save = np.array(self.buffer)
                  np.save(self.current_filename, data_to_save)
                  print(f"[RollingFileWriter] Saved {self.current_filename} with {len(self.buffer)} frames")

                  # 버퍼 초기화 및 시간 리셋
                  self.buffer = []
                  self.start_time = now

              # 입력된 데이터 길이만큼 처리 완료 신호
              return len(input_items[0])
    directory: '"astro"'
    interval_sec: '10'
    vector_length: vec
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(8192)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '0'
    fc: hydro
    fftsize: vec
    rate: thro
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: hydro
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: thro
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: thro
    stream_chans: hydro
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
